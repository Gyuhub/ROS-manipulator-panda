Commit message: Update

File: model/franka_panda_rviz.urdf (robot description, URDF)
Before this commit: robot panda, 11 links, 10 joints
Joints:
- joint panda_hand_joint: axis (none) -> 0 0 1
